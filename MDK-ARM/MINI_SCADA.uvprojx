# Keil uVision project MINI_SCADA.uvprojx, settings and files
target Multi Media Development Board V1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MINI_SCADA +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\SPI_Flash;..\USER\GLCD;..\USER\SysTick;..\USER\Net;..\USER\enc28j60;..\..\GLCD;..\USER\FreeRTOSV6.1.0;..\USER\FreeRTOSV6.1.0\include;..\USER\FreeRTOSV6.1.0\portable\MemMang;..\USER\FreeRTOSV6.1.0\portable\RVDS\ARM_CM3;..\USER\LCD;..\USER\STMFLASH;..\USER\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h scada_init.c
    ../USER/STMFLASH/: stmflash.c
  group GLCD
    ../USER/GLCD/: GLCD.c AsciiLib.c HzLib.c
  group SysTick
    ../USER/SysTick/: stm32f10x_systick.c systick.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group ETH
    ../USER/Net/: ip_arp_udp_tcp.c simple_server.c
    ../USER/enc28j60/: ENC28J60.C SPI.C
  group FreeRtos
    ../USER/FreeRTOSV6.1.0/: list.c queue.c tasks.c
    ../USER/FreeRTOSV6.1.0/portable/RVDS/ARM_CM3/: port.c
    ../USER/FreeRTOSV6.1.0/portable/MemMang/: heap_2.c
